## sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_PORT=23
CONFIG_EXAMPLE_WIFI_SSID="ES_Staff"
CONFIG_EXAMPLE_WIFI_PASSWORD="ES@puba45"
```
